# Keil uVision project project.uvprojx, settings and files
target project (6240000::V6.24::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g474vet6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G474xx
  c include: ..\..\bsp\include;..\..\hal;..\..\middleware;..\..\middleware\debug_monitor\include;..\..\third_party\filter\include;..\..\third_party\mb_rtu\include;..\..\third_party\pid\include;..\..\third_party\uart_control\include;..\..\third_party\bootloader\include;..\..\third_party\bootloader\port\stm32g4;..\..\drivers;..\..\drivers\ain_sensor\include;..\..\app;..\..\app\alarm_system\include;..\..\config;..\..\rtos\rt-thread\include;..\..\rtos\rt-thread\bsp;..\..\rtos\rt-thread\libcpu\arm\cortex-m4;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\mcal\STM32Cube_FW_G4_V1.6.0\Drivers\CMSIS\Include;..\..\utils\alarm\include;..\..\utils\check_algorithm\include;..\..\utils\debug\include;..\..\utils\ntc_temp\include;..\..\utils\platform\include;..\..\utils\rcm\include;..\..\utils\ring_buffer\include
  memory RVCT4: ROM 0x8000000 size 0x39800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp
    ../../bsp/src/: bsp_board.c system_stm32g4xx.c main.c bsp_isr.c
    ../../hal/: hal_cordic.c
    ../../bsp/startup/: startup_stm32g474xx.s
  group hal
    ../../hal/: hal.c hal_adc1.c hal_adc2.c hal_gpio.c hal_tim1.c hal_usart2.c hal_tim7.c hal_tim6.c
  group utils
    ../../utils/platform/src/: platform.c
    ../../utils/alarm/src/: alarm.c
    ../../third_party/filter/src/: filter.c
    ../../third_party/pid/src/: pid_controller.c
  group drivers
    ../../drivers/: drv.c
    ../../drivers/ain_sensor/src/: drv_ain_sensor.c
  group middleware
    ../../middleware/: middleware.c
    ../../middleware/debug_monitor/src/: debug_monitor.c dm_adapter.c
  group mcal/STM32G4xx_HAL_Driver
    ../../mcal/STM32Cube_FW_G4_V1.6.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_cordic.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group rtos/RT-Thread
    ../../rtos/rt-thread/bsp/: board.c
    ../../rtos/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../../rtos/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group third_party/uart_control
    ../../third_party/uart_control/src/: uart_control.c
  group third_party/mb_rtu
    ../../third_party/mb_rtu/src/: modbus_common.c modbus_slave.c modbus_master.c
  group third_party/pid
    ../../third_party/pid/src/: pid_float.c
  group third_party/bootloader
    ../../third_party/bootloader/src/: bl.c bl_crc.c bl_meta.c bl_download.c
    ../../third_party/bootloader/port/stm32g4/: bl_port_stm32g4.c
software components: CMSIS:CORE 5.6.0
